# Keil uVision project project.uvproj, settings and files
target PROJECT (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\BSP;..\usart;..\uC-CPU;..\uC-CPU\ARM-Cortex-M3;..\uC-LIB;..\uCOS-II\Ports;..\uCOS-II\Source;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriphDriver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/: bsp.c bsp_int.c
    ../BSP/usart/: usart.c usart.h
    ../BSP/sysTick/: sysTick.c sysTick.h
    ../BSP/I2C/: i2c.c i2c.h
    ../BSP/ultrasonic/: ultrasonic.c ultrasonic.h
    ../BSP/timer/: TIM4.c TIM4.h
  group uCCPU
    ../uC-CPU/ARM-Cortex-M3/: cpu_c.c cpu_a.asm
  group uCLib
    ../uC-LIB/: lib_mem.c lib_str.c
    ../uC-LIB/Ports/: lib_mem_a.asm
  group UCOSII
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group APP
    ../APP/: app.c stm32f10x_it.c
